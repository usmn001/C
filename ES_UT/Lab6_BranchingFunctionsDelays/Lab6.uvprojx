# Keil uVision project Lab6.uvprojx, settings and files
target Lab6 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab6
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Source
    ./: startup.s BranchingFunctionsDelays.c
  group Object code
    ./: texas.o
software components: CMSIS:CORE 4.3.0
